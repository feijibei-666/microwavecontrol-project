#include "lcd.h"
#include "delay.h"

#define LCD_RS_PORT     GPIOB
#define LCD_RS_PIN      GPIO_Pin_7
#define LCD_RST_PORT    GPIOB
#define LCD_RST_PIN     GPIO_Pin_8
#define LCD_CS_PORT     GPIOB
#define LCD_CS_PIN      GPIO_Pin_9

#define RS_H()          GPIO_SetBits(LCD_RS_PORT, LCD_RS_PIN)
#define RS_L()          GPIO_ResetBits(LCD_RS_PORT, LCD_RS_PIN)
#define RST_H()         GPIO_SetBits(LCD_RST_PORT, LCD_RST_PIN)
#define RST_L()         GPIO_ResetBits(LCD_RST_PORT, LCD_RST_PIN)
#define CS_H()          GPIO_SetBits(LCD_CS_PORT, LCD_CS_PIN)
#define CS_L()          GPIO_ResetBits(LCD_CS_PORT, LCD_CS_PIN)

/* 72 MHz / 8 = 9 MHz. Reduce this if long jumper wires are unreliable. */
#ifndef LCD_SPI_PRESCALER
#define LCD_SPI_PRESCALER SPI_BaudRatePrescaler_8
#endif
#define LCD_TRANSFER_TIMEOUT_MS  50
#define LCD_WAIT_SPIN_LIMIT      1000000UL
#define LCD_X_OFFSET             0
#define LCD_Y_OFFSET             0

#define CMD_SWRESET     0x01
#define CMD_SLPOUT      0x11
#define CMD_NORON       0x13
#define CMD_INVOFF      0x20
#define CMD_INVON       0x21
#define CMD_DISPON      0x29
#define CMD_CASET       0x2A
#define CMD_RASET       0x2B
#define CMD_RAMWR       0x2C
#define CMD_MADCTL      0x36
#define CMD_COLMOD      0x3A

volatile uint32_t lcd_fault_code = LCD_FAULT_NONE;
static uint8_t dma_line[LCD_W * 2];
static const uint8_t LCD_F8x16[][16];

static void LCD_Fault(uint32_t code)
{
    lcd_fault_code = code;
    SPI_I2S_DMACmd(SPI1, SPI_I2S_DMAReq_Tx, DISABLE);
    DMA_Cmd(DMA1_Channel3, DISABLE);
    DMA_ClearFlag(DMA1_FLAG_GL3);
    SPI_Cmd(SPI1, DISABLE);
    CS_H();
}

static uint8_t LCD_WaitSPI(uint16_t flag, FlagStatus expected)
{
    uint32_t start = delay_millis();
    uint32_t spins = LCD_WAIT_SPIN_LIMIT;

    while (SPI_I2S_GetFlagStatus(SPI1, flag) != expected)
    {
        if (((uint32_t)(delay_millis() - start) >= LCD_TRANSFER_TIMEOUT_MS) ||
            (--spins == 0))
        {
            LCD_Fault(LCD_FAULT_SPI_TIMEOUT);
            return 0;
        }
    }
    return 1;
}

static void LCD_GPIOInit(void)
{
    GPIO_InitTypeDef gpio;
    SPI_InitTypeDef spi;
    DMA_InitTypeDef dma;

    RCC_APB2PeriphClockCmd(RCC_APB2Periph_GPIOA | RCC_APB2Periph_GPIOB |
                          RCC_APB2Periph_SPI1, ENABLE);
    RCC_AHBPeriphClockCmd(RCC_AHBPeriph_DMA1, ENABLE);
    gpio.GPIO_Pin = GPIO_Pin_5 | GPIO_Pin_7;
    gpio.GPIO_Mode = GPIO_Mode_AF_PP;
    gpio.GPIO_Speed = GPIO_Speed_50MHz;
    GPIO_Init(GPIOA, &gpio);
    gpio.GPIO_Pin = LCD_RS_PIN | LCD_RST_PIN | LCD_CS_PIN;
    gpio.GPIO_Mode = GPIO_Mode_Out_PP;
    GPIO_Init(GPIOB, &gpio);
    CS_H();
    RS_H();
    RST_H();

    SPI_I2S_DeInit(SPI1);
    SPI_StructInit(&spi);
    spi.SPI_Direction = SPI_Direction_1Line_Tx;
    spi.SPI_Mode = SPI_Mode_Master;
    spi.SPI_DataSize = SPI_DataSize_8b;
    spi.SPI_CPOL = SPI_CPOL_High;
    spi.SPI_CPHA = SPI_CPHA_2Edge;
    spi.SPI_NSS = SPI_NSS_Soft;
    spi.SPI_BaudRatePrescaler = LCD_SPI_PRESCALER;
    spi.SPI_FirstBit = SPI_FirstBit_MSB;
    SPI_Init(SPI1, &spi);
    SPI_NSSInternalSoftwareConfig(SPI1, SPI_NSSInternalSoft_Set);
    SPI_Cmd(SPI1, ENABLE);

    DMA_DeInit(DMA1_Channel3);
    DMA_StructInit(&dma);
    dma.DMA_PeripheralBaseAddr = (uint32_t)&SPI1->DR;
    dma.DMA_MemoryBaseAddr = (uint32_t)dma_line;
    dma.DMA_DIR = DMA_DIR_PeripheralDST;
    dma.DMA_BufferSize = sizeof(dma_line);
    dma.DMA_PeripheralInc = DMA_PeripheralInc_Disable;
    dma.DMA_MemoryInc = DMA_MemoryInc_Enable;
    dma.DMA_PeripheralDataSize = DMA_PeripheralDataSize_Byte;
    dma.DMA_MemoryDataSize = DMA_MemoryDataSize_Byte;
    dma.DMA_Mode = DMA_Mode_Normal;
    dma.DMA_Priority = DMA_Priority_Low;
    dma.DMA_M2M = DMA_M2M_Disable;
    DMA_Init(DMA1_Channel3, &dma);
    DMA_ClearFlag(DMA1_FLAG_GL3);
}

static void LCD_WriteByte(uint8_t data)
{
    if ((lcd_fault_code != LCD_FAULT_NONE) ||
        !LCD_WaitSPI(SPI_I2S_FLAG_TXE, SET))
    {
        return;
    }
    SPI_I2S_SendData(SPI1, data);
    if (!LCD_WaitSPI(SPI_I2S_FLAG_TXE, SET))
    {
        return;
    }
    LCD_WaitSPI(SPI_I2S_FLAG_BSY, RESET);
}

static void LCD_WriteCmd(uint8_t cmd)
{
    if (lcd_fault_code != LCD_FAULT_NONE) return;
    CS_L();
    RS_L();
    LCD_WriteByte(cmd);
    CS_H();
}

static void LCD_WriteData(uint8_t data)
{
    if (lcd_fault_code != LCD_FAULT_NONE) return;
    CS_L();
    RS_H();
    LCD_WriteByte(data);
    CS_H();
}

static void LCD_SetWindow(uint16_t x, uint16_t y, uint16_t width, uint16_t height)
{
    uint16_t x0 = x + LCD_X_OFFSET;
    uint16_t x1 = x + width - 1 + LCD_X_OFFSET;
    uint16_t y0 = y + LCD_Y_OFFSET;
    uint16_t y1 = y + height - 1 + LCD_Y_OFFSET;

    LCD_WriteCmd(CMD_CASET);
    LCD_WriteData((uint8_t)(x0 >> 8)); LCD_WriteData((uint8_t)x0);
    LCD_WriteData((uint8_t)(x1 >> 8)); LCD_WriteData((uint8_t)x1);
    LCD_WriteCmd(CMD_RASET);
    LCD_WriteData((uint8_t)(y0 >> 8)); LCD_WriteData((uint8_t)y0);
    LCD_WriteData((uint8_t)(y1 >> 8)); LCD_WriteData((uint8_t)y1);
    LCD_WriteCmd(CMD_RAMWR);
}

/* The complete original ST7735 initialization sequence is retained. */
static void LCD_InitSequence(void)
{
    LCD_WriteCmd(CMD_SWRESET);
    delay_ms(120);
    LCD_WriteCmd(CMD_SLPOUT);
    delay_ms(120);
    LCD_WriteCmd(0xB1);
    LCD_WriteData(0x01); LCD_WriteData(0x2C); LCD_WriteData(0x2D);
    LCD_WriteCmd(0xB2);
    LCD_WriteData(0x01); LCD_WriteData(0x2C); LCD_WriteData(0x2D);
    LCD_WriteCmd(0xB3);
    LCD_WriteData(0x01); LCD_WriteData(0x2C); LCD_WriteData(0x2D);
    LCD_WriteData(0x01); LCD_WriteData(0x2C); LCD_WriteData(0x2D);
    LCD_WriteCmd(0xB4);
    LCD_WriteData(0x07);
    LCD_WriteCmd(0xC0);
    LCD_WriteData(0xA2); LCD_WriteData(0x02); LCD_WriteData(0x84);
    LCD_WriteCmd(0xC1);
    LCD_WriteData(0xC5);
    LCD_WriteCmd(0xC2);
    LCD_WriteData(0x0A); LCD_WriteData(0x00);
    LCD_WriteCmd(0xC3);
    LCD_WriteData(0x8A); LCD_WriteData(0x2A);
    LCD_WriteCmd(0xC4);
    LCD_WriteData(0x8A); LCD_WriteData(0xEE);
    LCD_WriteCmd(0xC5);
    LCD_WriteData(0x0E);
    LCD_WriteCmd(CMD_MADCTL);
    LCD_WriteData(0xC8);
    LCD_WriteCmd(CMD_COLMOD);
    LCD_WriteData(0x05);
    LCD_WriteCmd(0xE0);
    LCD_WriteData(0x02); LCD_WriteData(0x1C); LCD_WriteData(0x07); LCD_WriteData(0x12);
    LCD_WriteData(0x37); LCD_WriteData(0x32); LCD_WriteData(0x29); LCD_WriteData(0x2D);
    LCD_WriteData(0x29); LCD_WriteData(0x25); LCD_WriteData(0x2B); LCD_WriteData(0x39);
    LCD_WriteData(0x00); LCD_WriteData(0x01); LCD_WriteData(0x03); LCD_WriteData(0x10);
    LCD_WriteCmd(0xE1);
    LCD_WriteData(0x03); LCD_WriteData(0x1D); LCD_WriteData(0x07); LCD_WriteData(0x06);
    LCD_WriteData(0x2E); LCD_WriteData(0x2C); LCD_WriteData(0x2E); LCD_WriteData(0x2D);
    LCD_WriteData(0x2E); LCD_WriteData(0x2E); LCD_WriteData(0x37); LCD_WriteData(0x3F);
    LCD_WriteData(0x00); LCD_WriteData(0x00); LCD_WriteData(0x02); LCD_WriteData(0x10);
    LCD_WriteCmd(CMD_INVON);
    LCD_WriteCmd(CMD_NORON);
    LCD_WriteCmd(CMD_DISPON);
    delay_ms(100);
}

void LCD_Init(void)
{
    lcd_fault_code = LCD_FAULT_NONE;
    LCD_GPIOInit();
    RST_H(); delay_ms(10);
    RST_L(); delay_ms(10);
    RST_H(); delay_ms(120);
    LCD_InitSequence();
    LCD_Clear(LCD_BLACK);
}

/* DMA reads a single row from the small byte-order conversion buffer. The
 * caller holds CS/DC stable until the last SPI bit physically leaves the pin. */
static uint8_t LCD_SendLine(uint16_t width)
{
    uint32_t start = delay_millis();
    uint32_t spins = LCD_WAIT_SPIN_LIMIT;

    if (lcd_fault_code != LCD_FAULT_NONE) return 0;
    DMA_Cmd(DMA1_Channel3, DISABLE);
    DMA_ClearFlag(DMA1_FLAG_GL3);
    DMA_SetCurrDataCounter(DMA1_Channel3, (uint16_t)(width * 2));
    SPI_I2S_DMACmd(SPI1, SPI_I2S_DMAReq_Tx, ENABLE);
    DMA_Cmd(DMA1_Channel3, ENABLE);
    while (DMA_GetFlagStatus(DMA1_FLAG_TC3) == RESET)
    {
        if (DMA_GetFlagStatus(DMA1_FLAG_TE3) != RESET)
        {
            LCD_Fault(LCD_FAULT_DMA_TRANSFER);
            return 0;
        }
        if (((uint32_t)(delay_millis() - start) >= LCD_TRANSFER_TIMEOUT_MS) ||
            (--spins == 0))
        {
            LCD_Fault(LCD_FAULT_DMA_TIMEOUT);
            return 0;
        }
    }
    SPI_I2S_DMACmd(SPI1, SPI_I2S_DMAReq_Tx, DISABLE);
    DMA_Cmd(DMA1_Channel3, DISABLE);
    DMA_ClearFlag(DMA1_FLAG_GL3);
    if (!LCD_WaitSPI(SPI_I2S_FLAG_TXE, SET)) return 0;
    return LCD_WaitSPI(SPI_I2S_FLAG_BSY, RESET);
}

void LCD_Blit(uint16_t x, uint16_t y, uint16_t width, uint16_t height,
              const uint16_t *pixels)
{
    uint16_t source_width = width;
    uint16_t row, col, value;
    const uint16_t *source;

    if ((pixels == 0) || (x >= LCD_W) || (y >= LCD_H) ||
        (width == 0) || (height == 0) || (lcd_fault_code != LCD_FAULT_NONE)) return;
    if (width > LCD_W - x) width = (uint16_t)(LCD_W - x);
    if (height > LCD_H - y) height = (uint16_t)(LCD_H - y);
    LCD_SetWindow(x, y, width, height);
    if (lcd_fault_code != LCD_FAULT_NONE) return;
    CS_L(); RS_H();
    for (row = 0; row < height; row++)
    {
        source = pixels + (uint32_t)row * source_width;
        for (col = 0; col < width; col++)
        {
            value = source[col];
            dma_line[col * 2] = (uint8_t)(value >> 8);
            dma_line[col * 2 + 1] = (uint8_t)value;
        }
        if (!LCD_SendLine(width)) return;
    }
    CS_H();
}

void LCD_Fill(uint16_t x, uint16_t y, uint16_t width, uint16_t height, uint16_t color)
{
    uint16_t col, row;

    if ((x >= LCD_W) || (y >= LCD_H) || (width == 0) || (height == 0) ||
        (lcd_fault_code != LCD_FAULT_NONE)) return;
    if (width > LCD_W - x) width = (uint16_t)(LCD_W - x);
    if (height > LCD_H - y) height = (uint16_t)(LCD_H - y);
    for (col = 0; col < width; col++)
    {
        dma_line[col * 2] = (uint8_t)(color >> 8);
        dma_line[col * 2 + 1] = (uint8_t)color;
    }
    LCD_SetWindow(x, y, width, height);
    if (lcd_fault_code != LCD_FAULT_NONE) return;
    CS_L(); RS_H();
    for (row = 0; row < height; row++)
    {
        if (!LCD_SendLine(width)) return;
    }
    CS_H();
}

void LCD_Clear(uint16_t color)
{
    LCD_Fill(0, 0, LCD_W, LCD_H, color);
}

void LCD_DrawPoint(uint16_t x, uint16_t y, uint16_t color)
{
    LCD_Blit(x, y, 1, 1, &color);
}

uint8_t LCD_FontColumn(char ch, uint8_t column, uint8_t half)
{
    if ((ch < ' ') || (ch > '~') || (column >= 8) || (half >= 2)) return 0;
    return LCD_F8x16[(uint8_t)(ch - ' ')][column + half * 8];
}

void LCD_ShowChar(uint16_t x, uint16_t y, char ch, uint16_t fore, uint16_t back)
{
    uint16_t glyph[8 * 16];
    uint8_t i, j, bits;

    if ((x >= LCD_W) || (y >= LCD_H) || (LCD_W - x < 8) || (LCD_H - y < 16)) return;
    for (j = 0; j < 16; j++)
    {
        for (i = 0; i < 8; i++)
        {
            bits = LCD_FontColumn(ch, i, (uint8_t)(j / 8));
            glyph[j * 8 + i] = ((bits >> (j & 7)) & 1) ? fore : back;
        }
    }
    LCD_Blit(x, y, 8, 16, glyph);
}

void LCD_ShowString(uint16_t x, uint16_t y, const char *str, uint16_t fore, uint16_t back)
{
    if (str == 0) return;
    while ((*str != '\0') && (y <= LCD_H - 16))
    {
        LCD_ShowChar(x, y, *str++, fore, back);
        x += 8;
        if (x > LCD_W - 8)
        {
            x = 0;
            y += 16;
        }
    }
}

void LCD_ShowStringCenter(uint16_t y, const char *str, uint16_t fore, uint16_t back)
{
    uint16_t len = 0;
    if (str == 0) return;
    while (str[len] != '\0') len++;
    LCD_ShowString((len >= LCD_W / 8) ? 0 : (uint16_t)((LCD_W - len * 8) / 2),
                   y, str, fore, back);
}

/* Original 8x16 printable ASCII font, byte-for-byte unchanged. */
static const uint8_t LCD_F8x16[][16] =
{
    0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
    0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,

    0x00,0x00,0x00,0xF8,0x00,0x00,0x00,0x00,
    0x00,0x00,0x00,0x33,0x30,0x00,0x00,0x00,

    0x00,0x10,0x0C,0x06,0x10,0x0C,0x06,0x00,
    0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,

    0x40,0xC0,0x78,0x40,0xC0,0x78,0x40,0x00,
    0x04,0x3F,0x04,0x04,0x3F,0x04,0x04,0x00,

    0x00,0x70,0x88,0xFC,0x08,0x30,0x00,0x00,
    0x00,0x18,0x20,0xFF,0x21,0x1E,0x00,0x00,

    0xF0,0x08,0xF0,0x00,0xE0,0x18,0x00,0x00,
    0x00,0x21,0x1C,0x03,0x1E,0x21,0x1E,0x00,

    0x00,0xF0,0x08,0x88,0x70,0x00,0x00,0x00,
    0x1E,0x21,0x23,0x24,0x19,0x27,0x21,0x10,

    0x10,0x16,0x0E,0x00,0x00,0x00,0x00,0x00,
    0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,

    0x00,0x00,0x00,0xE0,0x18,0x04,0x02,0x00,
    0x00,0x00,0x00,0x07,0x18,0x20,0x40,0x00,

    0x00,0x02,0x04,0x18,0xE0,0x00,0x00,0x00,
    0x00,0x40,0x20,0x18,0x07,0x00,0x00,0x00,

    0x40,0x40,0x80,0xF0,0x80,0x40,0x40,0x00,
    0x02,0x02,0x01,0x0F,0x01,0x02,0x02,0x00,

    0x00,0x00,0x00,0xF0,0x00,0x00,0x00,0x00,
    0x01,0x01,0x01,0x1F,0x01,0x01,0x01,0x00,

    0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
    0x80,0xB0,0x70,0x00,0x00,0x00,0x00,0x00,

    0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
    0x00,0x01,0x01,0x01,0x01,0x01,0x01,0x01,

    0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
    0x00,0x30,0x30,0x00,0x00,0x00,0x00,0x00,

    0x00,0x00,0x00,0x00,0x80,0x60,0x18,0x04,
    0x00,0x60,0x18,0x06,0x01,0x00,0x00,0x00,

    0x00,0xE0,0x10,0x08,0x08,0x10,0xE0,0x00,
    0x00,0x0F,0x10,0x20,0x20,0x10,0x0F,0x00,

    0x00,0x10,0x10,0xF8,0x00,0x00,0x00,0x00,
    0x00,0x20,0x20,0x3F,0x20,0x20,0x00,0x00,

    0x00,0x70,0x08,0x08,0x08,0x88,0x70,0x00,
    0x00,0x30,0x28,0x24,0x22,0x21,0x30,0x00,

    0x00,0x30,0x08,0x88,0x88,0x48,0x30,0x00,
    0x00,0x18,0x20,0x20,0x20,0x11,0x0E,0x00,

    0x00,0x00,0xC0,0x20,0x10,0xF8,0x00,0x00,
    0x00,0x07,0x04,0x24,0x24,0x3F,0x24,0x00,

    0x00,0xF8,0x08,0x88,0x88,0x08,0x08,0x00,
    0x00,0x19,0x21,0x20,0x20,0x11,0x0E,0x00,

    0x00,0xE0,0x10,0x88,0x88,0x18,0x00,0x00,
    0x00,0x0F,0x11,0x20,0x20,0x11,0x0E,0x00,

    0x00,0x38,0x08,0x08,0xC8,0x38,0x08,0x00,
    0x00,0x00,0x00,0x3F,0x00,0x00,0x00,0x00,

    0x00,0x70,0x88,0x08,0x08,0x88,0x70,0x00,
    0x00,0x1C,0x22,0x21,0x21,0x22,0x1C,0x00,

    0x00,0xE0,0x10,0x08,0x08,0x10,0xE0,0x00,
    0x00,0x00,0x31,0x22,0x22,0x11,0x0F,0x00,

    0x00,0x00,0x00,0xC0,0xC0,0x00,0x00,0x00,
    0x00,0x00,0x00,0x30,0x30,0x00,0x00,0x00,

    0x00,0x00,0x00,0x80,0x00,0x00,0x00,0x00,
    0x00,0x00,0x80,0x60,0x00,0x00,0x00,0x00,

    0x00,0x00,0x80,0x40,0x20,0x10,0x08,0x00,
    0x00,0x01,0x02,0x04,0x08,0x10,0x20,0x00,

    0x40,0x40,0x40,0x40,0x40,0x40,0x40,0x00,
    0x04,0x04,0x04,0x04,0x04,0x04,0x04,0x00,

    0x00,0x08,0x10,0x20,0x40,0x80,0x00,0x00,
    0x00,0x20,0x10,0x08,0x04,0x02,0x01,0x00,

    0x00,0x70,0x48,0x08,0x08,0x08,0xF0,0x00,
    0x00,0x00,0x00,0x30,0x36,0x01,0x00,0x00,

    0xC0,0x30,0xC8,0x28,0xE8,0x10,0xE0,0x00,
    0x07,0x18,0x27,0x24,0x23,0x14,0x0B,0x00,

    0x00,0x00,0xC0,0x38,0xE0,0x00,0x00,0x00,
    0x20,0x3C,0x23,0x02,0x02,0x27,0x38,0x20,

    0x08,0xF8,0x88,0x88,0x88,0x70,0x00,0x00,
    0x20,0x3F,0x20,0x20,0x20,0x11,0x0E,0x00,

    0xC0,0x30,0x08,0x08,0x08,0x08,0x38,0x00,
    0x07,0x18,0x20,0x20,0x20,0x10,0x08,0x00,

    0x08,0xF8,0x08,0x08,0x08,0x10,0xE0,0x00,
    0x20,0x3F,0x20,0x20,0x20,0x10,0x0F,0x00,

    0x08,0xF8,0x88,0x88,0xE8,0x08,0x10,0x00,
    0x20,0x3F,0x20,0x20,0x23,0x20,0x18,0x00,

    0x08,0xF8,0x88,0x88,0xE8,0x08,0x10,0x00,
    0x20,0x3F,0x20,0x00,0x03,0x00,0x00,0x00,

    0xC0,0x30,0x08,0x08,0x08,0x38,0x00,0x00,
    0x07,0x18,0x20,0x20,0x22,0x1E,0x02,0x00,

    0x08,0xF8,0x08,0x00,0x00,0x08,0xF8,0x08,
    0x20,0x3F,0x21,0x01,0x01,0x21,0x3F,0x20,

    0x00,0x08,0x08,0xF8,0x08,0x08,0x00,0x00,
    0x00,0x20,0x20,0x3F,0x20,0x20,0x00,0x00,

    0x00,0x00,0x08,0x08,0xF8,0x08,0x08,0x00,
    0xC0,0x80,0x80,0x80,0x7F,0x00,0x00,0x00,

    0x08,0xF8,0x88,0xC0,0x28,0x18,0x08,0x00,
    0x20,0x3F,0x20,0x01,0x26,0x38,0x20,0x00,

    0x08,0xF8,0x08,0x00,0x00,0x00,0x00,0x00,
    0x20,0x3F,0x20,0x20,0x20,0x20,0x30,0x00,

    0x08,0xF8,0xF8,0x00,0xF8,0xF8,0x08,0x00,
    0x20,0x3F,0x00,0x3F,0x00,0x3F,0x20,0x00,

    0x08,0xF8,0x30,0xC0,0x00,0x08,0xF8,0x08,
    0x20,0x3F,0x20,0x00,0x07,0x18,0x3F,0x00,

    0xE0,0x10,0x08,0x08,0x08,0x10,0xE0,0x00,
    0x0F,0x10,0x20,0x20,0x20,0x10,0x0F,0x00,

    0x08,0xF8,0x08,0x08,0x08,0x08,0xF0,0x00,
    0x20,0x3F,0x21,0x01,0x01,0x01,0x00,0x00,

    0xE0,0x10,0x08,0x08,0x08,0x10,0xE0,0x00,
    0x0F,0x18,0x24,0x24,0x38,0x50,0x4F,0x00,

    0x08,0xF8,0x88,0x88,0x88,0x88,0x70,0x00,
    0x20,0x3F,0x20,0x00,0x03,0x0C,0x30,0x20,

    0x00,0x70,0x88,0x08,0x08,0x08,0x38,0x00,
    0x00,0x38,0x20,0x21,0x21,0x22,0x1C,0x00,

    0x18,0x08,0x08,0xF8,0x08,0x08,0x18,0x00,
    0x00,0x00,0x20,0x3F,0x20,0x00,0x00,0x00,

    0x08,0xF8,0x08,0x00,0x00,0x08,0xF8,0x08,
    0x00,0x1F,0x20,0x20,0x20,0x20,0x1F,0x00,

    0x08,0x78,0x88,0x00,0x00,0xC8,0x38,0x08,
    0x00,0x00,0x07,0x38,0x0E,0x01,0x00,0x00,

    0xF8,0x08,0x00,0xF8,0x00,0x08,0xF8,0x00,
    0x03,0x3C,0x07,0x00,0x07,0x3C,0x03,0x00,

    0x08,0x18,0x68,0x80,0x80,0x68,0x18,0x08,
    0x20,0x30,0x2C,0x03,0x03,0x2C,0x30,0x20,

    0x08,0x38,0xC8,0x00,0xC8,0x38,0x08,0x00,
    0x00,0x00,0x20,0x3F,0x20,0x00,0x00,0x00,

    0x10,0x08,0x08,0x08,0xC8,0x38,0x08,0x00,
    0x20,0x38,0x26,0x21,0x20,0x20,0x18,0x00,

    0x00,0x00,0x00,0xFE,0x02,0x02,0x02,0x00,
    0x00,0x00,0x00,0x7F,0x40,0x40,0x40,0x00,

    0x00,0x0C,0x30,0xC0,0x00,0x00,0x00,0x00,
    0x00,0x00,0x00,0x01,0x06,0x38,0xC0,0x00,

    0x00,0x02,0x02,0x02,0xFE,0x00,0x00,0x00,
    0x00,0x40,0x40,0x40,0x7F,0x00,0x00,0x00,

    0x00,0x00,0x04,0x02,0x02,0x02,0x04,0x00,
    0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,

    0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
    0x80,0x80,0x80,0x80,0x80,0x80,0x80,0x80,

    0x00,0x02,0x02,0x04,0x00,0x00,0x00,0x00,
    0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,

    0x00,0x00,0x80,0x80,0x80,0x80,0x00,0x00,
    0x00,0x19,0x24,0x22,0x22,0x22,0x3F,0x20,

    0x08,0xF8,0x00,0x80,0x80,0x00,0x00,0x00,
    0x00,0x3F,0x11,0x20,0x20,0x11,0x0E,0x00,

    0x00,0x00,0x00,0x80,0x80,0x80,0x00,0x00,
    0x00,0x0E,0x11,0x20,0x20,0x20,0x11,0x00,

    0x00,0x00,0x00,0x80,0x80,0x88,0xF8,0x00,
    0x00,0x0E,0x11,0x20,0x20,0x10,0x3F,0x20,

    0x00,0x00,0x80,0x80,0x80,0x80,0x00,0x00,
    0x00,0x1F,0x22,0x22,0x22,0x22,0x13,0x00,

    0x00,0x80,0x80,0xF0,0x88,0x88,0x88,0x18,
    0x00,0x20,0x20,0x3F,0x20,0x20,0x00,0x00,

    0x00,0x00,0x80,0x80,0x80,0x80,0x80,0x00,
    0x00,0x6B,0x94,0x94,0x94,0x93,0x60,0x00,

    0x08,0xF8,0x00,0x80,0x80,0x80,0x00,0x00,
    0x20,0x3F,0x21,0x00,0x00,0x20,0x3F,0x20,

    0x00,0x80,0x98,0x98,0x00,0x00,0x00,0x00,
    0x00,0x20,0x20,0x3F,0x20,0x20,0x00,0x00,

    0x00,0x00,0x00,0x80,0x98,0x98,0x00,0x00,
    0x00,0xC0,0x80,0x80,0x80,0x7F,0x00,0x00,

    0x08,0xF8,0x00,0x00,0x80,0x80,0x80,0x00,
    0x20,0x3F,0x24,0x02,0x2D,0x30,0x20,0x00,

    0x00,0x08,0x08,0xF8,0x00,0x00,0x00,0x00,
    0x00,0x20,0x20,0x3F,0x20,0x20,0x00,0x00,

    0x80,0x80,0x80,0x80,0x80,0x80,0x80,0x00,
    0x20,0x3F,0x20,0x00,0x3F,0x20,0x00,0x3F,

    0x80,0x80,0x00,0x80,0x80,0x80,0x00,0x00,
    0x20,0x3F,0x21,0x00,0x00,0x20,0x3F,0x20,

    0x00,0x00,0x80,0x80,0x80,0x80,0x00,0x00,
    0x00,0x1F,0x20,0x20,0x20,0x20,0x1F,0x00,

    0x80,0x80,0x00,0x80,0x80,0x00,0x00,0x00,
    0x80,0xFF,0xA1,0x20,0x20,0x11,0x0E,0x00,

    0x00,0x00,0x00,0x80,0x80,0x80,0x80,0x00,
    0x00,0x0E,0x11,0x20,0x20,0xA0,0xFF,0x80,

    0x80,0x80,0x80,0x00,0x80,0x80,0x80,0x00,
    0x20,0x20,0x3F,0x21,0x20,0x00,0x01,0x00,

    0x00,0x00,0x80,0x80,0x80,0x80,0x80,0x00,
    0x00,0x33,0x24,0x24,0x24,0x24,0x19,0x00,

    0x00,0x80,0x80,0xE0,0x80,0x80,0x00,0x00,
    0x00,0x00,0x00,0x1F,0x20,0x20,0x00,0x00,

    0x80,0x80,0x00,0x00,0x00,0x80,0x80,0x00,
    0x00,0x1F,0x20,0x20,0x20,0x10,0x3F,0x20,

    0x80,0x80,0x80,0x00,0x00,0x80,0x80,0x80,
    0x00,0x01,0x0E,0x30,0x08,0x06,0x01,0x00,

    0x80,0x80,0x00,0x80,0x00,0x80,0x80,0x80,
    0x0F,0x30,0x0C,0x03,0x0C,0x30,0x0F,0x00,

    0x00,0x80,0x80,0x00,0x80,0x80,0x80,0x00,
    0x00,0x20,0x31,0x2E,0x0E,0x31,0x20,0x00,

    0x80,0x80,0x80,0x00,0x00,0x80,0x80,0x80,
    0x80,0x81,0x8E,0x70,0x18,0x06,0x01,0x00,

    0x00,0x80,0x80,0x80,0x80,0x80,0x80,0x00,
    0x00,0x21,0x30,0x2C,0x22,0x21,0x30,0x00,

    0x00,0x00,0x00,0x00,0x80,0x7C,0x02,0x02,
    0x00,0x00,0x00,0x00,0x00,0x3F,0x40,0x40,

    0x00,0x00,0x00,0x00,0xFF,0x00,0x00,0x00,
    0x00,0x00,0x00,0x00,0xFF,0x00,0x00,0x00,

    0x00,0x02,0x02,0x7C,0x80,0x00,0x00,0x00,
    0x00,0x40,0x40,0x3F,0x00,0x00,0x00,0x00,

    0x00,0x06,0x01,0x01,0x02,0x02,0x04,0x04,
    0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
};
